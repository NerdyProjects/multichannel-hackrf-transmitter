options:
  parameters:
    generate_options: qt_gui
    id: try2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: Center frequency
    orient: Qt.Horizontal
    start: '87500000'
    step: '50000'
    stop: '900000000'
    value: '93400000'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: if_gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '1'
  states: {}
- name: if_samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '50'
    value: '0'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '10240000'
  states: {}
- name: s2_offset
  id: variable_qtgui_range
  parameters:
    label: offset
    orient: Qt.Horizontal
    start: '-5000000'
    step: '100000'
    stop: '5000000'
    value: '200000'
  states: {}
- name: s3_offset
  id: variable_qtgui_range
  parameters:
    label: offset
    orient: Qt.Horizontal
    start: '-5000000'
    step: '100000'
    stop: '5000000'
    value: '400000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: s2_offset
    offset: '0'
    phase: '0'
    samp_rate: if_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: s3_offset
    offset: '0'
    phase: '0'
    samp_rate: if_samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: analog_wfm_tx_0_0_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: stream1.fifo
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: stream2.fifo
    repeat: 'True'
    type: short
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: stream3.fifo
    repeat: 'True'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.000030'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.00003'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.00003'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '32768'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_short_to_float_0_0_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: center_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: rf_samp_rate
    sync: none
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: rf_samp_rate
    fc: center_freq
    fftsize: '1024'
    rate: '2'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_3_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_3_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '8'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_tx_0_0, '0', rational_resampler_xxx_1, '0']
- [analog_wfm_tx_0_0_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_2, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_file_source_0_0, '0', blocks_short_to_float_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_short_to_float_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_3, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_3_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', rational_resampler_xxx_3_0_0, '0']
- [blocks_multiply_const_vxx_2, '0', osmosdr_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '2']
- [blocks_short_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_float_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_short_to_float_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_1_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_const_vxx_2, '0']
- [rational_resampler_xxx_3, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_3_0, '0', analog_wfm_tx_0_0, '0']
- [rational_resampler_xxx_3_0_0, '0', analog_wfm_tx_0_0_0, '0']

metadata:
  file_format: 1
